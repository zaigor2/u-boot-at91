## board/emerson/ipro4/Kconfig
```kconfig
if TARGET_IPRO4

config SYS_BOARD
	default "ipro4"

config SYS_VENDOR
	default "emerson"

config SYS_CONFIG_NAME
	default "ipro4"

endif
```
